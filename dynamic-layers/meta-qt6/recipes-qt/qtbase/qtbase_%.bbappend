PACKAGECONFIG:append:class-target = " cups sql-sqlite"
