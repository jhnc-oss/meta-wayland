require cage.inc

DEPENDS += "\
    wlroots-0.19 \
"

SRCREV = "3da3ec0c2776594a546478f0fc31f96ef74e03ac"
