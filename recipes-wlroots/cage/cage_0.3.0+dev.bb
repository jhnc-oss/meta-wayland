require cage.inc

DEPENDS += "\
    wlroots-0.20 \
"

SRCREV = "79e1e0dfaad77f1ca096349a0f8b2666fbe3ee03"
