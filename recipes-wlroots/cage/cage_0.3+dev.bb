require cage.inc

DEPENDS += "\
    wlroots-0.20 \
"

SRCREV = "5491610293a59123710861330be92e4c2ec93840"
