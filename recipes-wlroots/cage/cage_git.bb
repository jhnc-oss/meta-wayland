require cage.inc

DEPENDS += "\
    wlroots-0.18 \
"

PV = "0.2.0+dev"
SRCREV = "19157d35649f96aa04d26036a76eaed65de60944"
