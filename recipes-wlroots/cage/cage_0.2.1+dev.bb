require cage.inc

DEPENDS += "\
    wlroots-0.19 \
"

SRCREV = "a1e5bf3789ece68ee703e93f3843906d29cad394"
