require cage.inc

DEPENDS += "\
    wlroots-0.18 \
"

SRCREV = "e128a9f2511644529fa47701a7147d65d9920488"
