require cage.inc

DEPENDS += "\
    wlroots-0.20 \
"

SRCREV = "3783af4fadc27057b24025fefe78d942e3f01128"
