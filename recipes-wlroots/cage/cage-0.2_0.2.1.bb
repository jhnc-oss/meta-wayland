require cage.inc

DEPENDS += "\
    wlroots-0.19 \
"

SRCREV = "f9626f79519f8ee22d7bb0c3880a66791d82f923"
