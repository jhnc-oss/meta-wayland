require cage.inc

DEPENDS += "\
    wlroots-0.20 \
"

SRCREV = "b7b774ac957b6d8c7b39f0dcb9ebe19de3e8a45d"
