SUMMARY = "muparser - fast math parser library"
HOMEPAGE = "https://github.com/beltoforion/muparser"
SECTION = "libs"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b4f961b32fec9e2001bbc01ad7bf04c4"

SRC_URI = "git://github.com/beltoforion/muparser.git;protocol=https;branch=master"

SRCREV = "fbafd7f8774af2b53f4d2de07c57353fcfc09216"

inherit cmake
