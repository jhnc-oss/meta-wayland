SUMMARY = "libdmtx - Open Source Data Matrix Software"
HOMEPAGE = "https://github.com/dmtx/libdmtx"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b58872aaf3a9d51c1f002b9d7940f4f1"

inherit autotools

SRC_URI = "git://github.com/dmtx/libdmtx.git;protocol=https;branch=master"
SRCREV = "500d7af6106713610a0f8b2d96aefa81912b96bc"
