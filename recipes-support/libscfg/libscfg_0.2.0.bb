SUMMARY = "A C library for scfg"
HOMEPAGE = "https://git.sr.ht/~emersion/libscfg"
LICENSE = "MIT"

LIC_FILES_CHKSUM = "file://LICENSE;md5=b32b698ab815d1913b4ed31d8c2ee8d7"

SRC_URI = "git://codeberg.org/emersion/libscfg;protocol=https;branch=master;tag=v0.2.0"

SRCREV = "f7d74ce6c81e55976d85b824ba73c03f6c0f157a"

inherit meson


