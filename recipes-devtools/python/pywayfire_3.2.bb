SUMMARY = "Python ipc bindings for wayfire"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=12a8965e31d96ba989d4294f1e2cd525"

inherit python_setuptools_build_meta

SRC_URI = "git://github.com/WayfireWM/pywayfire.git;protocol=https;branch=main"
SRCREV = "ee740229a76ecfa631efe7dff9ac8103c7fecd34"

